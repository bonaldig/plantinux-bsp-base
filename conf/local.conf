## conf/local.conf
```bitbake
MACHINE = "orangepi-zero3"

IMAGE_INSTALL:append = " e2fsprogs"

WKS_FILE_DEPENDS:append = " e2fsprogs-native"

VIRTUAL-RUNTIME_init_manager = "busybox"
```
